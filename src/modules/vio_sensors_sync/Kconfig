## src/modules/vio_sensors_sync/Kconfig
```kconfig
menuconfig MODULES_VIO_SENSORS_SYNC
	bool "vio_sensors_sync"
	default n
	---help---
```
